# Keil uVision project mcu_boot.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: mcu_boot +hex
  AfterMake: fromelf --bin --output .\obj\mcu_boot.bin .\obj\mcu_boot.axf
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F072,CODE_FOR_MCU_BOOT
  c include: ..\src;..\..\inc;..\..\inc\mcu;..\..\stm32lib\CMSIS\Device\Include;..\..\stm32lib\CMSIS\Include;..\..\stm32lib\STM32F0xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group MDK-ARM
    ../../stm32lib/CMSIS/Device/Source/Templates/arm/: startup_stm32f072.s
  group STM32F0xx_StdPeriph_Driver
    ../../stm32lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_iwdg.c stm32f0xx_pwr.c stm32f0xx_rtc.c
  group User
    ../src/: appl.h drv_uart_poll.c main.c stm32f0xx_it.c system_stm32f0xx.c
  group Mcu
    ../../mcu/src/: drv_wdog.c drv_flash.c drv_gpio.c drv_rtc.c
  group Common
    ../../common/: misc.c
